options:
  parameters:
    author: J1C
    category: '[Modulos_J1C_G5]'
    copyright: G5
    generate_options: hb
    id: EnvolventeComplejaPMJ1C
    output_language: python
    title: Envolvente Compleja PM J1C
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud de portadora
    type: eng_float
    value: '100e-3'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_1
  id: blocks_multiply_const_vxx
  parameters:
    const: kp
    type: float
  states: {}
- name: blocks_multiply_const_2
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_transcendental_1
  id: blocks_transcendental
  parameters:
    name: cos
    type: float
  states: {}
- name: blocks_transcendental_2
  id: blocks_transcendental
  parameters:
    name: sin
    type: float
  states: {}
- name: kp
  id: parameter
  parameters:
    label: Coeficiente de modulacion PM
    type: eng_float
    value: '1'
  states: {}
- name: pad_sink
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_2, '0']
- [blocks_multiply_const_1, '0', blocks_transcendental_1, '0']
- [blocks_multiply_const_1, '0', blocks_transcendental_2, '0']
- [blocks_multiply_const_2, '0', pad_sink, '0']
- [blocks_transcendental_1, '0', blocks_float_to_complex_0, '0']
- [blocks_transcendental_2, '0', blocks_float_to_complex_0, '1']
- [pad_source, '0', blocks_multiply_const_1, '0']

metadata:
  file_format: 1
